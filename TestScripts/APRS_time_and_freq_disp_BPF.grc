options:
  parameters:
    author: Handiko
    generate_options: qt_gui
    id: APRS_time_and_freq_disp
    output_language: python
    title: APRS - Time and Freq Display with BPF (Test)
  states: {}

blocks:
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '10.0'
    high_cutoff_freq: 2.6e3
    low_cutoff_freq: 1e3
    samp_rate: samp_rate
    type: band_pass
    width: '100.0'
    win: window.WIN_BLACKMAN
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    name: Input Spectrum
    showports: 'True'
    type: float
    width1: '2'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    legend: 'False'
    name: Input Waveform
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
  states: {}

connections:
- [audio_source_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
