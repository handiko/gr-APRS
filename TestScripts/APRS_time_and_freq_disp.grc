options:
  parameters:
    author: Handiko
    generate_options: qt_gui
    id: APRS_time_and_freq_disp
    output_language: python
    title: APRS - Time and Freq Display (Test)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    legend: 'False'
    name: Input Spectrum
    showports: 'True'
    type: float
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: ''
    legend: 'False'
    name: Input Waveform
    size: '512'
    srate: samp_rate
    type: float
    ymax: '0.1'
    ymin: '-0.1'
  states: {}

connections:
- [audio_source_0, '0', qtgui_freq_sink_x_0, '0']
- [audio_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
