options:
  parameters:
    author: Handiko
    generate_options: qt_gui
    id: APRS_AFSK_Demod
    output_language: python
    title: APRS - AFSK Demod (Test)
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '10.0'
    high_cutoff_freq: 2.6e3
    low_cutoff_freq: 1e3
    samp_rate: samp_rate
    type: band_pass
    width: '100.0'
    win: window.WIN_BLACKMAN
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: out_sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: space
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: AFSK_Demod_0
  id: AFSK_Demod
  parameters:
    baud: baud
    fsk_hi_tone: space
    fsk_lo_tone: mark
    in_sps: int(samp_rate / baud)
    out_sps: out_sps
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@0
    legend: 'False'
    name: Input Spectrum
    showports: 'True'
    type: float
    width1: '2'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: ''
    legend: 'False'
    name: Input Waveform
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1
    label1: ''
    legend: 'False'
    name: Demodulator Output
    size: '512'
    srate: baud*out_sps
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,1
    label0: Spectrum
    label1: Demodulator
    num_tabs: '2'
  states: {}

connections:
- [AFSK_Demod_0, '0', qtgui_time_sink_x_0_0, '0']
- [audio_source_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', AFSK_Demod_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
