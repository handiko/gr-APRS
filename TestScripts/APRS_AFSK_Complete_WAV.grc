options:
  parameters:
    author: Handiko
    generate_options: qt_gui
    id: APRS_AFSK_Complete_WAV
    output_language: python
    title: APRS - AFSK Decoder (Test)
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 2.6e3
    low_cutoff_freq: 1e3
    samp_rate: samp_rate
    type: band_pass
    width: '100.0'
    win: window.WIN_BLACKMAN
  states: {}
- name: gmu
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: out_sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: space
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: AFSK_Demod_0
  id: AFSK_Demod
  parameters:
    baud: baud
    fsk_hi_tone: space
    fsk_lo_tone: mark
    in_sps: int(samp_rate / baud)
    out_sps: out_sps
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate)
  states: {}
- name: blocks_and_const_xx_0
  id: blocks_and_const_xx
  parameters:
    const: '1'
    type: byte
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      File : gr-APRS/WAV/aprs.wav
      sample rate : 24 kHz
      bit depth : 16 bits
    file: D:\gr-APRS\WAV\aprs_random.wav
    repeat: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_hdlc_deframer_bp_0
  id: digital_hdlc_deframer_bp
  parameters:
    max: '500'
    min: '32'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.005'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: out_sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      from datetime import datetime

      # --- AX.25 SUPPORT CLASSES AND FUNCTIONS ---

      class AX25Address(object):
          def __init__(self):
              self.callsign = None
              self.ssid = None
              self.ch_bit = None
              self.reserved = None

          def __str__(self):
              if self.ssid == 0:
                  return self.callsign
              else:
                  return f"{self.callsign}-{self.ssid}"

          def to_bytes(self, last_addr=False, ch_bit=None):
              if self.callsign is None or not isinstance(self.ssid, int):
                  raise ValueError("Address fields not populated!")
              padded_cs = f"{self.callsign:<6}"
              array = bytearray([ord(c) << 1 for c in padded_cs])
              last_byte = self.ssid << 1
              if last_addr: last_byte |= 1
              if (ch_bit is None and self.ch_bit) or ch_bit: last_byte |= 0x80
              array.append(last_byte)
              return array

      class AX25Packet(object):
          def __init__(self):
              self.dest = None
              self.src = None
              self.digipeaters = []
              self.control = None
              self.frame_type = None
              self.protocol_id = None
              self.info = None

      def bytes_to_address(array):
          addr = AX25Address()
          addr.callsign = ''.join([chr(d >> 1) for d in array[0:6]]).strip()
          addr.ssid = (array[6] >> 1) & 0x0f
          last = True if (array[6] & 0x01) else False
          return (last, addr)

      def from_bytes(array):
          if len(array) < 15:
              raise ValueError("Packet too short")
          packet = AX25Packet()
          (last, packet.dest) = bytes_to_address(array[0:7])
          (last, packet.src) = bytes_to_address(array[7:14])
          offset = 14
          while not last:
              (last, addr_obj) = bytes_to_address(array[offset:offset+7])
              packet.digipeaters.append(addr_obj)
              offset += 7
          packet.control = array[offset]
          offset += 1
          # Check for UI frame or I frame which have protocol IDs
          if (packet.control & 0x03) == 0x03 or (packet.control & 0x01) == 0x00:
              packet.protocol_id = array[offset]
              offset += 1
          packet.info = array[offset:]
          return packet

      def dump_packet(packet):
          ret = f"{packet.src}>{packet.dest}"
          for station in packet.digipeaters:
              ret += f",{station}"
          # Use latin-1 to preserve binary APRS data/symbols
          info_str = packet.info.decode('latin-1', errors='replace')
          ret += f":{info_str}"
          return ret

      # --- GNU RADIO BLOCK ---

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name="HDLC to AX.25", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('hdlc in'))
              self.message_port_register_out(pmt.intern('ax25 out'))
              self.set_msg_handler(pmt.intern('hdlc in'), self.handle_msg)

          def handle_msg(self, msg_pmt):
              msg_py = pmt.to_python(msg_pmt)
              if not isinstance(msg_py, tuple) or len(msg_py) < 2:
                  return
              
              # Extract data from PDU (dict . vector)
              msg_data = bytearray(msg_py[1])

              try:
                  pkt = from_bytes(msg_data)
                  out_str = dump_packet(pkt)
                  
                  # 1. Print directly to GRC Console for easy reading
                  print(f"AX.25 Frame: {out_str}")
                  
                  # 2. Send as PDU to next block (with newline for logging)
                  pdu_str = out_str + '\n'
                  out_data = np.array([ord(c) for c in pdu_str], dtype=np.uint8)
                  self.message_port_pub(
                      pmt.intern('ax25 out'), 
                      pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(out_data), out_data))
                  )
                      
              except Exception as e:
                  # Uncomment for debugging parser errors:
                  # print(f"Parser Error: {e}")
                  pass

          def work(self, input_items, output_items):
              return 0
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: fff
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab@0:1,0,1,1
    legend: 'False'
    name: Input Spectrum
    showports: 'True'
    type: float
    width1: '2'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@0:0,0,1,1
    label1: ''
    legend: 'False'
    name: Input Waveform
    size: '1024'
    srate: samp_rate
    type: float
    width1: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:0,0,1,1
    label1: ''
    legend: 'False'
    name: Demodulator Output
    size: '512'
    srate: baud*out_sps
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tab@1:1,0,1,1
    label1: ''
    legend: 'False'
    name: Clock Sync Output
    size: '256'
    srate: baud
    type: float
    width1: '2'
    ymax: '5'
    ymin: '-5'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Input Signal
    label1: Demodulator Output
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: clock_sync
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: clock_sync
  states: {}

connections:
- [AFSK_Demod_0, '0', digital_symbol_sync_xx_0, '0']
- [AFSK_Demod_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_and_const_xx_0, '0', digital_hdlc_deframer_bp_0, '0']
- [blocks_not_xx_0, '0', blocks_and_const_xx_0, '0']
- [blocks_wavfile_source_0, '0', fft_filter_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_not_xx_0, '0']
- [digital_hdlc_deframer_bp_0, out, epy_block_0_0, hdlc in]
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [epy_block_0_0, ax25 out, network_socket_pdu_0, pdus]
- [fft_filter_xxx_0, '0', AFSK_Demod_0, '0']
- [fft_filter_xxx_0, '0', audio_sink_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
