options:
  parameters:
    author: Handiko
    description: www.github.com/handiko/gr-APRS
    generate_options: qt_gui
    id: APRS_RX_RTL
    output_language: python
    title: APRS - With RTL-SDR dongle
  states: {}

blocks:
- name: afgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: AF Gain (dB)
    min_len: '100'
    start: '-20'
    step: '0.1'
    stop: '-1'
    value: '-10.0'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: bb_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 2.6e3
    low_cutoff_freq: 1e3
    samp_rate: ch_rate
    type: band_pass
    width: '100.0'
    win: window.WIN_BLACKMAN
  states: {}
- name: ch_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: dev_ppm
  id: variable
  parameters:
    value: '35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 144.39e6 - samp_rate/4
  states: {}
- name: gmu
  id: variable
  parameters:
    value: '0.175'
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: mu
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rfgain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: RF Gain (dB)
    min_len: '100'
    start: '0'
    step: '1'
    stop: '49'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: space
  id: variable
  parameters:
    value: '2300'
  states: {}
- name: APRS_Rx_0
  id: APRS_Rx
  parameters:
    baud: baud
    bw: '0.045'
    dev: '1.0'
    df: '0.707'
    mark: mark
    samp_rate: ch_rate
    space: space
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '0.5'
    decay_rate: '10e-6'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.1'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: ch_rate/(2*math.pi*12e3/8.0)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pow(10.0,afgain/10.0)
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-math.pi/2'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import struct
      from datetime import datetime

      # --- AX.25 SUPPORT CLASSES AND FUNCTIONS ---

      class AX25Address(object):
          def __init__(self):
              self.callsign = None
              self.ssid = None
              self.ch_bit = None
              self.reserved = None

          def __str__(self):
              if self.ssid == 0:
                  return self.callsign
              else:
                  return f"{self.callsign}-{self.ssid}"

          def to_bytes(self, last_addr=False, ch_bit=None):
              if self.callsign is None or not isinstance(self.ssid, int):
                  raise ValueError("Address fields not populated!")
              padded_cs = f"{self.callsign:<6}"
              array = bytearray([ord(c) << 1 for c in padded_cs])
              last_byte = self.ssid << 1
              if last_addr: last_byte |= 1
              if (ch_bit is None and self.ch_bit) or ch_bit: last_byte |= 0x80
              array.append(last_byte)
              return array

      class AX25Packet(object):
          def __init__(self):
              self.dest = None
              self.src = None
              self.digipeaters = []
              self.control = None
              self.frame_type = None
              self.protocol_id = None
              self.info = None

      def bytes_to_address(array):
          addr = AX25Address()
          addr.callsign = ''.join([chr(d >> 1) for d in array[0:6]]).strip()
          addr.ssid = (array[6] >> 1) & 0x0f
          last = True if (array[6] & 0x01) else False
          return (last, addr)

      def from_bytes(array):
          if len(array) < 15:
              raise ValueError("Packet too short")
          packet = AX25Packet()
          (last, packet.dest) = bytes_to_address(array[0:7])
          (last, packet.src) = bytes_to_address(array[7:14])
          offset = 14
          while not last:
              (last, addr_obj) = bytes_to_address(array[offset:offset+7])
              packet.digipeaters.append(addr_obj)
              offset += 7
          packet.control = array[offset]
          offset += 1
          # Check for UI frame or I frame which have protocol IDs
          if (packet.control & 0x03) == 0x03 or (packet.control & 0x01) == 0x00:
              packet.protocol_id = array[offset]
              offset += 1
          packet.info = array[offset:]
          return packet

      def dump_packet(packet):
          ret = f"{packet.src}>{packet.dest}"
          for station in packet.digipeaters:
              ret += f",{station}"
          # Use latin-1 to preserve binary APRS data/symbols
          info_str = packet.info.decode('latin-1', errors='replace')
          ret += f":{info_str}"
          return ret

      # --- GNU RADIO BLOCK ---

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self, name="HDLC to AX.25", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.intern('hdlc in'))
              self.message_port_register_out(pmt.intern('ax25 out'))
              self.set_msg_handler(pmt.intern('hdlc in'), self.handle_msg)

          def handle_msg(self, msg_pmt):
              msg_py = pmt.to_python(msg_pmt)
              if not isinstance(msg_py, tuple) or len(msg_py) < 2:
                  return
              
              # Extract data from PDU (dict . vector)
              msg_data = bytearray(msg_py[1])

              try:
                  pkt = from_bytes(msg_data)
                  out_str = dump_packet(pkt)
                  
                  # 1. Print directly to GRC Console for easy reading
                  print(f"AX.25 Frame: {out_str}")
                  
                  # 2. Send as PDU to next block (with newline for logging)
                  pdu_str = out_str + '\n'
                  out_data = np.array([ord(c) for c in pdu_str], dtype=np.uint8)
                  self.message_port_pub(
                      pmt.intern('ax25 out'), 
                      pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(out_data), out_data))
                  )
                      
              except Exception as e:
                  # Uncomment for debugging parser errors:
                  # print(f"Parser Error: {e}")
                  pass

          def work(self, input_items, output_items):
              return 0
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import socket
      import threading
      import time

      class blk(gr.sync_block):
          def __init__(self, callsign='N0CALL', passcode='-1', 
                       lat='0000.00N', lon='00000.00E', 
                       comment='GNU Radio I-Gate',
                       beacon_interval=600, 
                       server='rotate.aprs.net', port=14580):
              
              gr.sync_block.__init__(self, name='APRS-IS I-Gate', in_sig=None, out_sig=None)
              
              # Parameters
              self.callsign = callsign
              self.passcode = passcode
              self.lat = lat  
              self.lon = lon  
              self.comment = comment # New user-configurable comment
              self.beacon_interval = beacon_interval
              self.server = server
              self.port = port
              
              # Internal State
              self.sock = None
              self.connected = False
              self.running = True

              # Message Port
              self.message_port_register_in(pmt.intern('pdu_in'))
              self.set_msg_handler(pmt.intern('pdu_in'), self.handle_msg)

              # Start Networking Thread
              self.net_thread = threading.Thread(target=self.network_loop)
              self.net_thread.daemon = True
              self.net_thread.start()

          def connect(self):
              try:
                  self.sock = socket.socket(socket.AF_INET, socket.SOCK_STREAM)
                  self.sock.settimeout(10)
                  self.sock.connect((self.server, self.port))
                  # Login String
                  login = f"user {self.callsign} pass {self.passcode} vers GRC-IGate 1.1\r\n"
                  self.sock.sendall(login.encode('ascii'))
                  self.connected = True
                  print(f"[I-Gate] Connected to {self.server} as {self.callsign}")
              except Exception as e:
                  print(f"[I-Gate] Connection failed: {e}")
                  self.connected = False

          def network_loop(self):
              last_beacon = 0
              while self.running:
                  if not self.connected:
                      self.connect()
                      time.sleep(15) 
                      continue
                  
                  now = time.time()
                  if (now - last_beacon) > self.beacon_interval:
                      # APRS Position Report: !Lat/Lon&Comment
                      # '!' is the Data Type ID
                      # '/' is the Symbol Table ID
                      # '&' is the Symbol Code (Map icon for I-Gate)
                      beacon_pkt = f"{self.callsign}>APRS,TCPIP*:!{self.lat}/{self.lon}&{self.comment}\r\n"
                      self.send_to_aprs(beacon_pkt)
                      last_beacon = now
                  
                  time.sleep(1)

          def send_to_aprs(self, packet_str):
              if self.connected and self.sock:
                  try:
                      self.sock.sendall(packet_str.encode('ascii'))
                  except:
                      self.connected = False
                      print("[I-Gate] Connection lost. Attempting reconnect...")

          def handle_msg(self, msg_pmt):
              try:
                  msg_py = pmt.to_python(msg_pmt)
                  # Handle both PMT pairs (PDU) and strings
                  if isinstance(msg_py, tuple):
                      raw_str = "".join(map(chr, msg_py[1]))
                  else:
                      raw_str = str(msg_py)

                  # Extract TNC2 data
                  if "AX.25 Frame: " in raw_str:
                      tnc2_data = raw_str.split("AX.25 Frame: ")[1].strip()
                  else:
                      tnc2_data = raw_str.strip()

                  if tnc2_data and ":" in tnc2_data:
                      header, payload = tnc2_data.split(":", 1)
                      # Inject I-Gate path (qAR) and forward to APRS-IS
                      formatted_pkt = f"{header},qAR,{self.callsign}:{payload}\r\n"
                      self.send_to_aprs(formatted_pkt)
                          
              except Exception as e:
                  # Silently ignore malformed frames to keep the console clean
                  pass

          def stop(self):
              self.running = False
              if self.sock:
                  self.sock.close()
              return True
    beacon_interval: '60'
    callsign: '"YB1SDL"'
    comment: '"::GNU Radio APRS I-Gate::"'
    lat: '"0622.07S"'
    lon: '"10649.01E"'
    passcode: '24511'
    port: '14580'
    server: '"rotate.aprs.net"'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    comment: |-
      PLEASE ADJUST THE FREQ CORRECTION 
      (PPM) TO A PROPER VALUE
    corr0: dev_ppm
    freq0: freq
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.8'
    average: '0.2'
    bw: 192e3
    fc: 144.39e6
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,2
    legend: 'False'
    name: RF Spectrum
    showports: 'True'
    type: complex
    width1: '2'
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.8'
    average: '0.2'
    bw: 8e3
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 1,2,2,1
    legend: 'False'
    name: AF Spectrum
    showports: 'True'
    type: float
    width1: '2'
    ymax: '20'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    legend: 'False'
    name: Clock Recovery
    size: '512'
    srate: '1200'
    type: float
    width1: '2'
    ymax: '2.1'
    ymin: '-2.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 192e3
    color1: '3'
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,2,1,1
    int_max: '-20'
    int_min: '-105'
    legend: 'False'
    name: RF Waterfall
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(ch_rate)
    interp: '8000'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '1'
    type: ccc
  states: {}

connections:
- [APRS_Rx_0, '0', qtgui_time_sink_x_0, '0']
- [APRS_Rx_0, HDLC, epy_block_0_0, hdlc in]
- [analog_agc2_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', fft_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_2, '0']
- [epy_block_0_0, ax25 out, epy_block_1, pdu_in]
- [fft_filter_xxx_0, '0', APRS_Rx_0, '0']
- [fft_filter_xxx_0, '0', analog_agc2_xx_1, '0']
- [fft_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_rotator_cc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_1, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
