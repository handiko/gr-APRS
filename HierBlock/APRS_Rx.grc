<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>APRS_Rx</value></param>
<param><key>author</key><value>Handiko </value></param>
<param><key>category</key><value>APRS</value></param>
<param><key>description</key><value>www.github.com/handiko/gr-APRS</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>APRS Rx</value></param>
</block>
<block>
<key>AFSK_Demod</key>
<param><key>id</key><value>AFSK_Demod_0</value></param>
<param><key>baud</key><value>baud</value></param>
<param><key>fsk_hi_tone</key><value>space</value></param>
<param><key>fsk_lo_tone</key><value>mark</value></param>
<param><key>in_sps</key><value>int(samp_rate/baud)</value></param>
<param><key>out_sps</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baud</value></param>
<param><key>label</key><value>Baudrate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>blocks_and_const_xx</key>
<param><key>id</key><value>blocks_and_const_xx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>gain_mu</key><value>gmu</value></param>
<param><key>gain_omega</key><value>0.25*gmu*gmu</value></param>
<param><key>mu</key><value>mu</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>omega</key><value>2*(1+0.0)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_hdlc_deframer_bp</key>
<param><key>id</key><value>digital_hdlc_deframer_bp_0</value></param>
<param><key>max</key><value>500</value></param>
<param><key>min</key><value>32</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import os, pty
import struct

import pmt
import numpy as np
from gnuradio import gr

import packet


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """
    Converts an array of bytes into a AX25Packet object.

    Connect to the "HDLC Deframer", or a block which emits a PMT tuple of
    (None, bytearray)
    """
    def __init__(self):
        gr.sync_block.__init__(self,
                               name="HDLC to AX.25",
                               in_sig=None,
                               out_sig=None)
        self.message_port_register_in(pmt.intern('hdlc in'))
        self.message_port_register_out(pmt.intern('ax25 out'))
        self.set_msg_handler(pmt.intern('hdlc in'), self.handle_msg)

    def handle_msg(self, msg_pmt):
        msg_pmt = pmt.pmt_to_python.pmt_to_python(msg_pmt)

        msg = bytearray(msg_pmt[1])

        try:
            pkt = packet.from_bytes(msg)
            self.message_port_pub(pmt.intern('ax25 out'), pmt.cons(pmt.make_dict(), pmt.pmt_to_python.numpy_to_uvector(np.array([ord(c) for c in (packet.dump(pkt) + '\n')], np.uint8))))
                
        except ValueError as e:
            print e

    def stop(self):
        gr.sync_block.stop(self)
        
    def work(self, input_items, output_items):
        in0 = input_items[0]
        # &lt;+signal processing here+&gt;
        return len(input_items[0])
        
        
        
</value></param>
<param><key>comment</key><value>Pyhton module which required 
to run this script (gr-APRS/Module/packet.py)
need to be copied to the 
/usr/lib/python2.7 directory</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gmu</value></param>
<param><key>label</key><value>Gain Mu</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.175</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mark</value></param>
<param><key>label</key><value>Mark Freq (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mu</value></param>
<param><key>label</key><value>Mu</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ax25</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>HDLC</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Clock Sync</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>Demodulator</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>afsk in</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>24e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>space</value></param>
<param><key>label</key><value>Space Freq (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2400</value></param>
</block>
<connection><source_block_id>AFSK_Demod_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>AFSK_Demod_0</source_block_id><sink_block_id>pad_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_and_const_xx_0</source_block_id><sink_block_id>digital_hdlc_deframer_bp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0</source_block_id><sink_block_id>blocks_and_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>blocks_not_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>out</source_key><sink_key>hdlc in</sink_key></connection>
<connection><source_block_id>digital_hdlc_deframer_bp_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>epy_block_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>ax25 out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>AFSK_Demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
