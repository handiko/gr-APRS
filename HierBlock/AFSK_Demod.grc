options:
  parameters:
    author: Handiko
    category: APRS
    generate_options: hb
    id: AFSK_Demod
    output_language: python
    title: Filterbank AFSK Demodulator
  states: {}

blocks:
- name: attack
  id: variable
  parameters:
    value: 0.5 + 0*1e-4
  states: {}
- name: decay
  id: variable
  parameters:
    value: 10e-6 + 0*2e-2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud*in_sps
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: attack
    decay_rate: decay
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: float
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: attack
    decay_rate: decay
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: float
  states: {}
- name: baud
  id: parameter
  parameters:
    label: Baudrate
    type: intx
    value: '1200'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-1.0*fsk_lo_tone/samp_rate)*2*math.pi
  states: {}
- name: blocks_rotator_cc_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-1.0*fsk_hi_tone/samp_rate)*2*math.pi
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: fsk_hi_tone
  id: parameter
  parameters:
    label: FSK "0" Tone
    type: eng_float
    value: '2200'
  states: {}
- name: fsk_lo_tone
  id: parameter
  parameters:
    label: FSK "1" Tone
    type: eng_float
    value: '1200'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: in_sps
  id: parameter
  parameters:
    label: Input Samples per Symbol
    type: intx
    value: '40'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1500'
    decim: '1'
    gain: '1.0'
    samp_rate: in_sps*1200.0
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: out_sps
  id: parameter
  parameters:
    label: Output Samples per Symbol
    type: intx
    value: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: demod out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: afsk in
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: in_sps
    interp: out_sps
    taps: ''
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.7'
    decim: '1'
    gain: '1'
    ntaps: 4*in_sps
    samp_rate: in_sps*1.0
    sym_rate: '1.0'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.7'
    decim: '1'
    gain: '1'
    ntaps: 4*in_sps
    samp_rate: in_sps*1.0
    sym_rate: '1.0'
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: symbol_hi
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: symbol_lo
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: symbol_hi
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: symbol_lo
  states: {}

connections:
- [analog_agc2_xx_0, '0', virtual_sink_1, '0']
- [analog_agc2_xx_1, '0', virtual_sink_2, '0']
- [blocks_complex_to_mag_0, '0', analog_agc2_xx_0, '0']
- [blocks_complex_to_mag_1, '0', analog_agc2_xx_1, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_rotator_cc_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_rotator_cc_1, '0', root_raised_cosine_filter_1, '0']
- [blocks_sub_xx_2, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [pad_source_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_0, '0', pad_sink_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_complex_to_mag_0, '0']
- [root_raised_cosine_filter_1, '0', blocks_complex_to_mag_1, '0']
- [virtual_source_0, '0', blocks_rotator_cc_0, '0']
- [virtual_source_1, '0', blocks_rotator_cc_1, '0']
- [virtual_source_2, '0', blocks_sub_xx_2, '0']
- [virtual_source_3, '0', blocks_sub_xx_2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
